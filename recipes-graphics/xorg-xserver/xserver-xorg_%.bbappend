# bbb does not have code for graphics acceleration -> disable glamor
OPENGL_PKGCONFIGS_bbone = "dri glx"
